Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-01-05T22:42:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 05 22:42:50 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\ed7aecd7-8c07-4f11-930e-4bf14866c118\511208af-79d1-407e-aa6b-758c89884ddf\ifc * Database version: 5507 * Database creation date: Thu Jan 05 22:42:49 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 05 22:42:49 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 05 22:42:49 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12179830_OER_KFN4898AD_BS:38489812_OER_12179830_KFN4898AD_BS, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 38489812_OER_12179830_KFN4898AD_BS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 38489812_OER_12179830_KFN4898AD_BS
Type - Pset_ProvisionForVoid - Width: 600 mm; Height: 2010 mm; Depth: 685 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_Cast, z_Miele_Design_BST, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_355623
Description: Flow; FlowDirection: SOURCEANDSINK
